FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " \
            file://0010-Handle-interface-without-ifa_addr.patch \
"

