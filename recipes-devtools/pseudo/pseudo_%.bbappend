FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://lstat-check-fix.patch"
