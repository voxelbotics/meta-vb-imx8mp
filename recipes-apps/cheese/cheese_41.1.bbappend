FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://0001-Stop-createing-duplicated-CameraDevice.patch"
