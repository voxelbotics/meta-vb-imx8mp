COMPATIBLE_MACHINE = "(imx8mpevk|imx8mpnavq)"