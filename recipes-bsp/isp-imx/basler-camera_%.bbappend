do_install:append() {
	rm ${D}/opt/imx8-isp/bin/dewarp_config/sensor_dwe_bypass_1080P_config.json
}
