FILESEXTRAPATHS:prepend := "${THISDIR}/kernel-module-nxp-wlan:"

SRC_URI += "file://Disable-MMSG.patch"
