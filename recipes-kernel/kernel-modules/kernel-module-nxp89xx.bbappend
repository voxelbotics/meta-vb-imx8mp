FILESEXTRAPATHS:prepend := "${THISDIR}/kernel-module-nxp89xx:"

SRC_URI += "file://Disable-MMSG.patch"
